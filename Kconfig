## Kconfig
```kconfig
menu "I2CDEV_CPP"

config I2CDEV_CPP_TIMEOUT
    int "I2C transaction timeout, milliseconds"
    default 1000
    range 100 5000
    
endmenu
```
